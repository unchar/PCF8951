# Keil uVision project PCF8591.uvproj, settings and files
target Target 1 (MCS-51)
  device: STC89C52RC STC
  cpu: IRAM(0-0xFF) XRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(45000000) MODP2
  output: PCF8591 +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: DA.c DA.h I2C.c I2C.H lcd12864.c delay_ms.h delay_ms.c main.c
